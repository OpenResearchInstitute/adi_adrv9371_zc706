options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: dvbs2_tx
    output_language: python
  states: {}

blocks:
- name: bb_frame_length
  id: variable
  parameters:
    comment: Must be updated to match the code rate setting in the BBheader block.
    value: '384'
  states: {}
- name: mode_word
  id: variable
  parameters:
    comment: Dummy value for now
    value: (0xaa,0xbb,0xcd,0xef)
  states: {}
- name: root_filename
  id: variable
  parameters:
    value: '"QPSK-1-4-3.6588"'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: root_filename+".ts4"
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: root_filename+".ts"
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (4,bb_frame_length)
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: mode_word
  states: {}
- name: dtv_dvb_bbheader_bb_0
  id: dtv_dvb_bbheader_bb
  parameters:
    framesize2: FECFRAME_SHORT
    rate5: C1_4
    rolloff: RO_0_35
    standard: STANDARD_DVBS2
  states: {}

connections:
- [blocks_file_source_0, '0', dtv_dvb_bbheader_bb_0, '0']
- [blocks_stream_mux_0, '0', blocks_file_sink_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_stream_mux_0, '1']
- [blocks_vector_source_x_0, '0', blocks_stream_mux_0, '0']
- [dtv_dvb_bbheader_bb_0, '0', blocks_unpacked_to_packed_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
